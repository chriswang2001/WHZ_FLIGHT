# Keil uVision project FLIGHT.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: FLIGHT
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 v6Lto=1
  c define: USE_HAL_DRIVER,STM32F401xE,ARM_MATH_CM4
  c include: ..\uCOS;..\LIB\Inc;..\HAL;..\APP;..\DRIVER;..\FLIGHT
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group APP
    ../APP/: main.c main.h
  group DRIVER
    ../DRIVER/: ano.c ano.h motor.c motor.h remote.c remote.h sensor.c sensor.h sys.c sys.h
  group FLIGHT
    ../FLIGHT/: ahrs.c ahrs.h pid.c pid.h
  group HAL
    ../HAL/: stm32f4xx_hal_conf.h stm32f4xx_hal_msp.c adc.c adc.h dma.c dma.h gpio.c gpio.h i2c.c i2c.h tim.c tim.h usart.c usart.h stm32f4xx_it.c stm32f4xx_it.h
  group LIB
    ../LIB/: startup_stm32f401xe.s system_stm32f4xx.c arm_cortexM4lf_math.lib
    ../LIB/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_cortex.c
  group uCOS
    ../UCOS/: ucos_ii.c
    ../uCOS/: os_cpu_a.asm os_cpu_c.c app_cfg.h app_hooks.c os_cfg.h os_dbg.c
